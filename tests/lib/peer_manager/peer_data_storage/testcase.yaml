## tests/lib/peer_manager/peer_data_storage/testcase.yaml
```yaml
tests:
  lib.peer_manager.peer_data_storage:
    platform_allow: native_sim
    tags: unittest
```
